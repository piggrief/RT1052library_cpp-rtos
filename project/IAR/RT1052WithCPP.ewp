# IAR project RT1052WithCPP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MIMXRT1052xxx6A NXP MIMXRT1052xxx6A
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: DEBUG; SKIP_SYSCLK_INIT; SDRAM_MPU_INIT; CPU_MIMXRT1052DVL6B; PRINTF_FLOAT_ENABLE=0; SCANF_FLOAT_ENABLE=0; XIP_EXTERNAL_FLASH=1; PRINTF_ADVANCED_ENABLE=0; SCANF_ADVANCED_ENABLE=0; SDK_I2C_BASED_COMPONENT_USED=1; XIP_EXTERNAL_FLASH=1; XIP_BOOT_HEADER_ENABLE=1; XIP_BOOT_HEADER_DCD_ENABLE=0; _DLIB_FILE_DESCRIPTOR; __cplusplus
  ICCARM.CCIncludePath2: ..\..\fsl\drivers; ..\..\fsl\CMSIS\Include; ..\..\fsl\utilities; ..\..\fsl\utilities\log; ..\..\fsl\utilities\io; ..\..\fsl\utilities\str; ..\..\base; ..\..\app; ..\..\app\Pig_Function; ..\..\board; ..\..\drivers\LQ_drivers; ..\..\drivers\LQ_drivers\sys; ..\..\drivers\Pig_drivers; ..\..\rtos; ..\..\rtos\Source\include; ..\..\rtos\Source\portable\MemMang; ..\..\rtos\Source\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: ..\..\rtos
  OBJCOPY.OOCOutputFile: RT1052WithCPP.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\base\icf\LQ_RT1052QSPI_Boot.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group app
    ../../app/: fsl_include.h include.h
    ./: main.cpp
  group app/Pig_Function
    ../../app/Pig_Function/: DebugFuction.c DebugFunction.h
  group borad
    ../../board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS
    ../../base/: system_MIMXRT1052.c system_MIMXRT1052.h
  group drivers/LQ_drives
    ../../drivers/LQ_drivers/: LQ_ADC.c LQ_ADC.h LQ_Encoder.c LQ_Encoder.h LQ_GPIOmacro.h LQ_IIC.c LQ_IIC.h LQ_KEY.c LQ_KEY.h LQ_LED.c LQ_LED.h LQ_MPU6050.c LQ_MPU6050.h LQ_PIT.c LQ_PIT.h LQ_PWM.c LQ_PWM.h LQ_QTMR.c LQ_QTMR.h LQ_SPI.c LQ_SPI.h LQ_TRNG.c LQ_TRNG.h LQ_UART.c LQ_UART.h LQ_WDog.c LQ_WDog.h
  group drivers/LQ_drives/AHRS
    ../../drivers/LQ_drivers/sys/: AHRS.c AHRS.h AP_Math.c AP_Math.h Inertial_Sensor.c Inertial_Sensor.h
  group drivers/LQ_drives/LCD
    ../../drivers/LQ_drivers/: LQ_SGP18T.c LQ_SGP18T.h
  group drivers/LQ_drives/system
    ../../drivers/LQ_drivers/sys/: m_systime.c m_systime.h status.c status.h
  group drivers/Pig_drives
    ../../app/: PORT_CFG.h
  group drivers/Pig_drives/SPI
    ../../drivers/Pig_drivers/: Pig_SPI.c Pig_SPI.h
  group drivers/Pig_drives/TFT1.44
    ../../drivers/Pig_drivers/: TFTDriver.c TFTDriver.h
  group drivers/Pig_drives/UART
    ../../drivers/Pig_drivers/: Pig_UART.c Pig_UART.h
  group fsl_drivers
    ../../fsl/drivers/: fsl_adc.c fsl_adc.h fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_csi.c fsl_csi.h fsl_dmamux.c fsl_dmamux.h fsl_edma.c fsl_edma.h fsl_enc.c fsl_enc.h fsl_flexio.c fsl_flexio.h fsl_flexio_spi.c fsl_flexio_spi.h fsl_flexio_spi_edma.c fsl_flexio_spi_edma.h fsl_gpio.c fsl_gpio.h fsl_gpt.c fsl_gpt.h fsl_iomuxc.h fsl_lpi2c.c fsl_lpi2c.h fsl_lpspi.c fsl_lpspi.h fsl_lpspi_edma.c fsl_lpspi_edma.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pit.c fsl_pit.h fsl_pwm.c fsl_pwm.h fsl_qtmr.c fsl_qtmr.h fsl_sccb.c fsl_sccb.h fsl_semc.c fsl_semc.h fsl_trng.c fsl_trng.h fsl_usdhc.c fsl_usdhc.h fsl_wdog.c fsl_wdog.h fsl_xbara.c fsl_xbara.h
  group rtos
    ../../rtos/: FreeRTOSConfig.h
  group rtos/port
    ../../rtos/Source/portable/IAR/ARM_CM4F/: fsl_tickless_generic.h fsl_tickless_systick.c port.c portasm.s portmacro.h
    ../../rtos/Source/portable/MemMang/: heap_4.c
  group rtos/source
    ../../rtos/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group startup
    ../../base/: startup_MIMXRT1052.s
  group utilities
    ../../fsl/utilities/: fsl_assert.c fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../fsl/utilities/io/: fsl_io.c fsl_io.h
    ../../fsl/utilities/log/: fsl_log.c fsl_log.h
    ../../fsl/utilities/str/: fsl_str.c fsl_str.h
